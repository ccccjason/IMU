# IAR project Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: C:\Users\tanji_000\Desktop\FY_Demo; C:\Users\tanji_000\Desktop\FY_Demo\Hardware; C:\Users\tanji_000\Desktop\FY_Demo\Libraries; C:\Users\tanji_000\Desktop\FY_Demo\Libraries\STM32F0xx_StdPeriph_Driver\inc; C:\Users\tanji_000\Desktop\FY_Demo\Libraries\CMSIS; C:\Users\tanji_000\Desktop\FY_Demo\Hardware\硬件IIC; C:\Users\tanji_000\Desktop\FY_Demo\User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Demo.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Attitute
    ../Hardware/: HMC5883.c HMC5883.h MPU6500.c MPU6500.h
    ../Hardware/硬件IIC/: I2C_hard.c I2C_hard.h
    ../User/: IMU.c IMU.h
  group Doc
    ../Doc/: readme.txt
  group EWARM
    ../Libraries/CMSIS/: startup_stm32f0xx.s
  group Hardware
    ../Hardware/: board.c board.h delay.c delay.h flash.c flash.h key.c key.h led.c led.h rf24l01.c rf24l01.h spi.c spi.h timer.c timer.h uart.c uart.h usart2.c usart2.h
  group StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crc.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group User
    ../User/: main.c
    ../: stm32f0xx_conf.h
    ../Libraries/CMSIS/: stm32f0xx_it.c system_stm32f0xx.c
